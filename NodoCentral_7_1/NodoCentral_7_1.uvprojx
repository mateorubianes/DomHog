# Keil uVision project NodoCentral_7_1.uvprojx, settings and files
target NodoCentral_7_1 (6070000::V6.7::.\ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: CPUTYPE("Cortex-M0+")
  output: NodoCentral_7_1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: ARM_MATH_CM0PLUS DEVICE_PORTIN=1 __MBED__=1 TARGET_LIKE_MBED MBED_RAM_START=0x1ffff000 TARGET_RELEASE TARGET_KLXX TARGET_Freescale DEVICE_SEMIHOST=1 TARGET_KL25Z TARGET_M0P MBED_RAM_SIZE=0x4000 DEVICE_I2C=1 TOOLCHAIN_ARM TOOLCHAIN_ARMC6 DEVICE_SPISLAVE=1 DEVICE_ANALOGIN=1 DEVICE_INTERRUPTIN=1 TARGET_LIKE_CORTEX_M0 MULADDC_CANNOT_USE_R7 DEVICE_STDIO_MESSAGES=1 DEVICE_SPI=1 DEVICE_PORTOUT=1 TARGET_CORTEX_M MBED_MINIMAL_PRINTF MBED_ROM_SIZE=0x20000 DEVICE_ANALOGOUT=1 DEVICE_I2CSLAVE=1 DEVICE_PORTINOUT=1 DEVICE_PWMOUT=1 MBED_BUILD_TIMESTAMP=1665527896.3366888 __CORTEX_M0PLUS __MBED_CMSIS_RTOS_CM __CMSIS_RTOS TARGET_FF_ARDUINO __ASSERT_MSG TARGET_CORTEX MBED_TRAP_ERRORS_ENABLED=1 DEVICE_SLEEP=1 DEVICE_SERIAL=1 DEVICE_USTICKER=1 TOOLCHAIN_ARM_STD TARGET_NAME=KL25Z MBED_ROM_START=0x0
  c misc: -fno-exceptions -fno-c++-static-destructors -mthumb -mcpu=cortex-m0plus -fshort-wchar --target=arm-arm-none-eabi -fshort-enums -fno-rtti -Wno-armcc-pragma-push-pop -c -fdata-sections -Wno-armcc-pragma-anon-unions -Wno-deprecated-register -Wno-reserved-user-defined-literal -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;TextLCD;mbed;mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-D__CORTEX_M0PLUS,-DARM_MATH_CM0PLUS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: --predefine="-DMBED_RAM_START=0x1ffff000" --predefine="-DMBED_ROM_START=0x0" --predefine="-DMBED_RAM_SIZE=0x4000" --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_ROM_SIZE=0x20000" --inline --show_full_path --any_contingency --legacyalign --predefine="-DMBED_BOOT_STACK_SIZE=4096" --keep=os_cb_sections --cpu=Cortex-M0plus
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o arm_math.h clk_freqs.h cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h except.o gpio_api.o gpio_irq_api.o gpio_object.h i2c_api.o mbed.ar mbed_board.o mbed_cmsis_conf.h mbed_fault_handler.h mbed_fault_handler.o mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o MKL25Z4.h mpu_armv7.h mpu_armv8.h objects.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pinmap.o PinNames.h port_api.o PortNames.h pwmout_api.o rtc_api.o RTE_Components.h serial_api.o sleep.o spi_api.o startup_MKL25Z4.o system_MKL25Z4.h system_MKL25Z4.o tz_context.h us_ticker.o
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h CThunkBase.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_crash_data_offsets.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
  group NodoCentral_7_1
    ./: main.cpp mbed_config.h
  group TextLCD
    TextLCD/: TextLCD.cpp TextLCD.h
